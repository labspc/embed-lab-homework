# Keil uVision project Project.uvprojx, settings and files
target STM32100E-EVAL_RCT6 (6210000::V6.21::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32100E-EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL;..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../Utilities/STM32_EVAL/Common/: stm32_eval_spi_sd.c stm32_eval_i2c_ee.c stm32_eval_i2c_tsensor.c stm32_eval_sdio_sd.c stm32_eval_spi_flash.c
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c stm3210e_eval_fsmc_sram.c stm3210e_eval_fsmc_nand.c stm3210e_eval_fsmc_nor.c
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c stm3210c_eval_ioe.c
    ../../../Utilities/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c stm32100b_eval_cec.c
    ../../../Utilities/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval_lcd.c stm32100e_eval_ioe.c stm32100e_eval_cec.c stm32100e_eval_fsmc_onenand.c stm32100e_eval_fsmc_sram.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 6.0.0
